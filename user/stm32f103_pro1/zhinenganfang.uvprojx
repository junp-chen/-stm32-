# Keil uVision project zhinenganfang.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zhinenganfang +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\CORE;..\..\STM32F10x_FWLib\inc;..\..\system\delay;..\..\system\sys;..\..\system\usart;..\stm32f103_pro1;..\..\HARDWARE\ds18b20;..\..\HARDWARE\oled;..\..\HARDWARE\mq_2;..\..\HARDWARE\adc;..\..\HARDWARE\BEEP;..\..\HARDWARE\dac;..\..\HARDWARE\dma;..\..\HARDWARE\ds18b20;..\..\HARDWARE\exti;..\..\HARDWARE\hc_sr501;..\..\HARDWARE\KEY;..\..\HARDWARE\LED;..\..\HARDWARE\mq_2;..\..\HARDWARE\oled;..\..\HARDWARE\pwm;..\..\HARDWARE\sim900a;..\..\HARDWARE\usart2;..\..\HARDWARE\TIME;..\..\HARDWARE\usart3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: system_stm32f10x.c stm32f10x_it.c main.c
  group CORE
    ../../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../../system/delay/: delay.c
    ../../system/sys/: sys.c
    ../../system/usart/: usart.c
  group HEADWARE
    ../../HARDWARE/adc/: adc.c
    ../../HARDWARE/BEEP/: beep.c
    ../../HARDWARE/dac/: dac.c
    ../../HARDWARE/dma/: dma.c
    ../../HARDWARE/ds18b20/: ds18b20.c
    ../../HARDWARE/hc_sr501/: hc_sr501.c
    ../../HARDWARE/exti/: exti.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/mq_2/: mq_2.c
    ../../HARDWARE/oled/: my_oled.c
    ../../HARDWARE/pwm/: pwm.c
    ../../HARDWARE/usart3/: usart3.c sim9001.c
    ../../HARDWARE/TIME/: my_time.c
    ../../HARDWARE/LED/: LED.C
